# Keil uVision project UnmannedVehicle.uvproj, settings and files
target STM32F411 (ARM-ADS)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(100000000) ELITTLE
  output: UnmannedVehicle
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c misc: --C99
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Embeded_Project\MyStm_Lib\inc;..\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../: system_stm32f4xx.c
  group User
    ../: main.c stm32f4xx_it.c
    ../../../Embeded_Project/MyStm_Lib/src/: Encoder.c stm32f4xx_delay.c USART_DMA_Config.c functions.c E_Compass.c srf05.c stm32f411_RCCEnable.c TwoWheelRobot.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_flash.c
